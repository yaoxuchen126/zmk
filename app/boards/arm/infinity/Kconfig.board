## app/boards/arm/infinity/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_INFINITY
	bool "infinity"
	depends on SOC_NRF52840_QIAA
```
